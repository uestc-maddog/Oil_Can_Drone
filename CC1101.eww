<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RX\CC1101_RX.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TX\CC1101_TX.ewp</path>
  </project>
  <batchBuild/>
</workspace>


