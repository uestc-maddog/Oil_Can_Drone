<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>APP</name>
    <file>
      <name>$PROJ_DIR$\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8l10x_it.c</name>
    </file>
  </group>
  <group>
    <name>BSP</name>
    <file>
      <name>$PROJ_DIR$\..\BSP\bsp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BSP\OLED.c</name>
    </file>
  </group>
  <group>
    <name>DRIVER</name>
    <group>
      <name>CPU</name>
      <file>
        <name>$PROJ_DIR$\..\DRIVER\CPU\STM8L_LIB_V1.2.0\src\stm8l10x_awu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\DRIVER\CPU\STM8L_LIB_V1.2.0\src\stm8l10x_beep.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\DRIVER\CPU\STM8L_LIB_V1.2.0\src\stm8l10x_clk.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\DRIVER\CPU\STM8L_LIB_V1.2.0\src\stm8l10x_comp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\DRIVER\CPU\STM8L_LIB_V1.2.0\src\stm8l10x_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\DRIVER\CPU\STM8L_LIB_V1.2.0\src\stm8l10x_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\DRIVER\CPU\STM8L_LIB_V1.2.0\src\stm8l10x_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\DRIVER\CPU\STM8L_LIB_V1.2.0\src\stm8l10x_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\DRIVER\CPU\STM8L_LIB_V1.2.0\src\stm8l10x_irtim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\DRIVER\CPU\STM8L_LIB_V1.2.0\src\stm8l10x_itc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\DRIVER\CPU\STM8L_LIB_V1.2.0\src\stm8l10x_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\DRIVER\CPU\STM8L_LIB_V1.2.0\src\stm8l10x_rst.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\DRIVER\CPU\STM8L_LIB_V1.2.0\src\stm8l10x_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\DRIVER\CPU\STM8L_LIB_V1.2.0\src\stm8l10x_tim2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\DRIVER\CPU\STM8L_LIB_V1.2.0\src\stm8l10x_tim3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\DRIVER\CPU\STM8L_LIB_V1.2.0\src\stm8l10x_tim4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\DRIVER\CPU\STM8L_LIB_V1.2.0\src\stm8l10x_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\DRIVER\CPU\STM8L_LIB_V1.2.0\src\stm8l10x_wfe.c</name>
      </file>
    </group>
    <group>
      <name>RF</name>
      <file>
        <name>$PROJ_DIR$\..\DRIVER\RF\CC1101.c</name>
      </file>
    </group>
  </group>
</project>


