# IAR project Backup of CC1101_RX.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L101F3P STM8L101F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\BSP; ..\DRIVER\CPU\STM8L_LIB_V1.2.0\inc; ..\DRIVER\CPU\STM8L_LIB_V1.2.0; ..\DRIVER\RF
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: CC1101_RX.hex
  ILINK.IlinkOutputFile: CC1101_RX.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group APP
    ./: main.c stm8l10x_it.c
  group BSP
    ../BSP/: bsp.c OLED.c
  group DRIVER/CPU
    ../DRIVER/CPU/STM8L_LIB_V1.2.0/src/: stm8l10x_awu.c stm8l10x_beep.c stm8l10x_clk.c stm8l10x_comp.c stm8l10x_exti.c stm8l10x_flash.c stm8l10x_gpio.c stm8l10x_i2c.c stm8l10x_irtim.c stm8l10x_itc.c stm8l10x_iwdg.c stm8l10x_rst.c stm8l10x_spi.c stm8l10x_tim2.c stm8l10x_tim3.c stm8l10x_tim4.c stm8l10x_usart.c stm8l10x_wfe.c
  group DRIVER/RF
    ../DRIVER/RF/: CC1101.c
